# Keil uVision project LAB_003.uvprojx, settings and files
target NXP LPC4088 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_003
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group Library
    ./Library/: SystemStructures.h PWM.c GPIO.c Joystick.c PLL.h PLL.c Timer.c Ultrasonic.c Timer.h Ultrasonic.h ADC.c ADC.h SystemTickTimer.c SystemTickTimer.h Controller.c Controller.h ESP8266.c LED.c Serial.c WIFI.c I2C.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
